# Repository ddo02/EasyInjection

File README.md:

# EasyInjection
EasyInjection is a module to drive fuel injectors (or other loads). It has 5 channels.

Some aftermarket EFIs has only low power signal output to activate injectors.

So, an external driver is needed. The EasyInjection can be this driver.

EasyInjection works perfectly with MegaSquirt EFI.

# Technical Information
EasyInjection is based on VND5N07.

VND5N07 is a power MOSFET fully autoprotected. 

It's a great option to drive fuel injectors with a minimum set of components.

EasyInjection can be used with high-z injectors, but some low-z injectors can be used (specially if use a in serie resistor), because VND5N07 supplies up to 5A.

The project was developed using Kicad EDA.

# Usage
EasyInjection works switching the ground (GND).

Pins 6 and 12 must be connected to a good engine ground.

### Input signals (from EFI):

- Channel 1: Pin 1
- Channel 2: Pin 2
- Channel 3: Pin 3
- Channel 4: Pin 4
- Channel 5: Pin 5

### Output (to injector):

- Channel 1: Pin 7
- Channel 2: Pin 8
- Channel 3: Pin 9
- Channel 4: Pin 10
- Channel 5: Pin 11

More than one injector can be drive by channel, with 5A current limit for each channel.

More than one module can be used, to drive more injectors.

# License
This project is under dual-license.

First license is for commercial use of this project. To build a product, based on this project, and sell it.

Second license is for non-commercial use of this project. To build a sample, to personal use or education use.

# Donate

## KiCad design PCB/EasyInjection.kicad_pcb

Parts:
J1: Conn_02x06_Top_Bottom; Molex_Mini-Fit_Jr_5566-12A_2x06_P4.20mm_Vertical
R1, R3, R5, R7, R9: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2, R4, R6, R8, R10: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
S1, S2, S3, S4, S5: VND5N07; VND5N07_TO-252-(DPAK); Manufacturer_Part_Number VND5N07-E

Connections:
CTRL_1: J1.1, R1.2
CTRL_2: J1.2, R3.2
CTRL_3: J1.3, R9.2
CTRL_4: J1.4, R7.2
CTRL_5: J1.5, R5.2
GNDPWR: J1.6, J1.12, R2.2, R4.2, R6.2, R8.2, R10.2, S1.3 (S), S2.3 (S), S3.3 (S), S4.3 (S), S5.3 (S)
unnamed: R1.1, R2.1, S1.1 (G)
unnamed: R3.1, R4.1, S2.1 (G)
unnamed: R5.1, R6.1, S5.1 (G)
unnamed: R7.1, R8.1, S4.1 (G)
unnamed: R9.1, R10.1, S3.1 (G)
OUT_1: J1.7, S1.2 (D)
OUT_2: J1.8, S2.2 (D)
OUT_3: J1.9, S3.2 (D)
OUT_4: J1.10, S4.2 (D)
OUT_5: J1.11, S5.2 (D)

Board: 2 copper layers, 61.2 x 54.1 mm, 16 parts (5 on the bottom side), 16 nets.

## Commit log

2018-03-11 Licenses
2018-03-11 Initial project
2018-03-11 Project rename. Lib add. Initial schematic.
2018-03-11 Version 1.0 done!
2018-03-11 Schematic PNG added
2019-11-07 Changed to 5 channels
